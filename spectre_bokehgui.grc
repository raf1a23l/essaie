<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>bokeh_gui</value></param>
</block>
<block>
<key>variable_bokehgui_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>100</value></param>
<param><key>end</key><value>160</value></param>
<param><key>label</key><value>""</value></param>
<param><key>start</key><value>60</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>throttle</key><value>1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>bokehgui_frequency_sink_x</key>
<param><key>id</key><value>bokehgui_frequency_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>axislabels</key><value>True</value></param>
<param><key>bw</key><value>10</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>2072</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>True</value></param>
<param><key>alpha1</key><value>1.0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>None</value></param>
<param><key>style1</key><value>"solid"</value></param>
<param><key>width1</key><value>1</value></param>
<param><key>alpha2</key><value>1.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>None</value></param>
<param><key>style2</key><value>"solid"</value></param>
<param><key>width2</key><value>1</value></param>
<param><key>maxhold</key><value>False</value></param>
<param><key>name</key><value>""</value></param>
<param><key>nconnections</key><value>1</value></param>
<param><key>placement</key><value>(1,0)</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>tr_chan</key><value>0</value></param>
<param><key>tr_level</key><value>0.0</value></param>
<param><key>tr_mode</key><value>bokehgui.TRIG_MODE_FREE</value></param>
<param><key>tr_tag</key><value>""</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>100</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>xlabel</key><value>Frequency</value></param>
<param><key>xunit</key><value>"Mhz"</value></param>
<param><key>ylabel</key><value>Relative Gain</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-140</value></param>
<param><key>yunit</key><value>dB</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>freq0</key><value>(center_freq)*1e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>bokehgui_frequency_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
